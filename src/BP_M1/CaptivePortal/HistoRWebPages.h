#ifndef _HistoRWebPages_H_
#define _HistoRWebPages_H_

#define FSH(x) (__FlashStringHelper*)(x)

#define MULTI_LINE_STRING(...) #__VA_ARGS__

const char HistoRHomePage[] PROGMEM = MULTI_LINE_STRING(<!DOCTYPE html>
<html>
<head>
<title>HistoR - Home Page</title>
</head>
<body>
<h1>HistoR v0.1 - Embedded system for receiving audio streams on a historic radio receiver</h1>
<hr>
<div> 
    <h2>Music player</h2>
    <p>Currently playing: <input type="text" id="Mplayer" name="Mplayer" value="" size="100" disabled></p>
    <form action="./" onsubmit="return false;">
        <input type="hidden" name="CMD" value="MPSELECT">
        <input type="hidden" id="CMD2" name="CMD2" value="SAVEPLAY">
        <input type="radio" id="MP_SDcard" name="MPselected" value="MP_SDcard">
        <label for="MP_SDcard">SD card</label> - <a href="./SDSELECT">select track</a> -- 
        <span>
            <input type="submit" value="< Prev">
            <input type="submit" value="I> Play/ II Pause">
            <input type="submit" value="Next >"> --
            <label for="MP_RANDOM">Random play</label>
            <input type="checkbox" id="MP_RANDOM" name="MP_RANDOM" value="MPrandomplay">
            <label for="MP_REPEAT_ALL">Repeat all</label>
            <input type="checkbox" id="MP_REPEAT_ALL" name="MP_REPEAT_ALL" value="MPrepeatall">
            <label for="MP_REPEAT_ONE">Repeat one</label>
            <input type="checkbox" id="MP_REPEAT_ONE" name="MP_REPEAT_ONE" value="MPrepeatone">
        </span><br>
        <input type="radio" id="MP_Internet" name="MPselected" value="MP_Internet">
        <label for="MP_Internet">Internet</label> - <label for="INT_URL">URL: </label><input type="text" id="INT_URL" name="INT_URL" value="https://ice5.abradio.cz/hitvysocina128.mp3" size="40"><br>
        <input type="radio" id="MP_Bluetooth" name="MPselected" value="MP_Bluetooth">
        <label for="MP_Bluetooth">Bluetooth</label> - <label for="BT_NAME">name: </label><input type="text" id="BT_NAME" name="BT_NAME" value="HistoR" size="10"><!--- - <input type="submit" value="on/off">---><br>
        <input type="radio" id="MP_Radio" name="MPselected" value="MP_Radio">
        <label for="MP_Radio">Radio</label> - <label for="R_FREQ">frequency: </label><input type="text" id="R_FREQ" name="R_FREQ" value="99.7" size="5"><br>
        <label for="MP_AUTO" title="After device start, automatically starts last audio source">Autoplay: </label>
        <input type="checkbox" id="MP_AUTO" name="MP_AUTO" value="MPautoplay"> - <label for="MP_VOLUME">Volume: </label><input type="number" id="MP_VOLUME" name="MP_VOLUME" min="0" max="21" value="" size="5"/><br>
        <input type="submit" id="MPSavePlay" value="Save & Play">
        <input type="submit" id="MPSave" value="Save">
        <input type="submit" id="MPStop" value="Stop"><br>
    </form>
</div>
<div> 
    <h2>FM & AM transmitter</h2>
    <form action="./">
        <input type="hidden" name="CMD" value="TRANS">
        <label for="FM_ACTIVE">FM active: </label>
        <input type="checkbox" id="FM_ACTIVE" name="FM_ACTIVE" value="FMactive"><br>
        <label for="FM_FREQ">frequency:</label>
        <input type="text" id="FM_FREQ" name="FM_FREQ" value="92.40" size="5"><br><br>
        <label for="AM_ACTIVE">AM active: </label>
        <input type="checkbox" id="AM_ACTIVE" name="AM_ACTIVE" value="AMactive"><br>
        <input type="submit" value="Save">
    </form>
</div>
<br>
<hr>
<div> 
    <h2>WIFI settings</h2>
    <form action="./">
		<a href="./WIFISCAN" target="_blank">wifi scan</a><br><br>
        <input type="hidden" name="CMD" value="WIFI">
        <label for="WIFI_SSID">SSID:</label><br>
        <input type="text" id="WIFI_SSID" name="SSID"> (at least 8 chars)<br>
        <label for="WIFI_SSID">Password:</label><br>
        <input type="text" id="WIFI_PASSWORD" name="PASSWORD"> (at least 8 chars)<br>
        <input type="submit" name="submit" value="Save">
    </form>
</div>
<div> 
    <h2>AP settings</h2>
    <form action="./">
        <input type="hidden" name="CMD" value="AP">
        <label for="AP_ACTIVE">AP active: </label>
        <input type="checkbox" id="AP_ACTIVE" name="ACTIVE" value="APactive"><br>
        <label for="AP_SSID">SSID:</label><br>
        <input type="text" id="AP_SSID" name="SSID"> (at least 8 chars)<br>
        <label for="AP_PASSWORD">Password:</label><br>
        <input type="text" id="AP_PASSWORD" name="PASSWORD"> (at least 8 chars)<br>
        <input type="submit" name="submit" value="Save">
    </form>
</div>
<div> 
    <h2>Restart HistoR</h2>
    <form id="FORM_RESTART" action="./">
        <input type="hidden" name="CMD" value="RESTART">
		Restart to apply changes: 
        <input type="submit" name="submit" value="Restart">
    </form>
</div>
</body>
<script>
document.getElementById("MPSavePlay").addEventListener("click", async (e) => {
	document.getElementById("CMD2").value = "SAVEPLAY";
});

document.getElementById("MPSave").addEventListener("click", async (e) => {
	document.getElementById("CMD2").value = "SAVE";
});

document.getElementById("MPStop").addEventListener("click", async (e) => {
	document.getElementById("CMD2").value = "STOP";
});

document.querySelectorAll('form').forEach( el => {
	el.addEventListener("submit", async (e) => {
		e.preventDefault();

		var form_query = "./API/?";

		for(var i = 0; i < e.target.length; i++) {
			console.log(e.target[i]);
			if (e.target[i].name == ""){
				continue;
			}
			if (e.target[i].type == 'checkbox') {
				form_query += e.target[i].name + "=" + e.target[i].checked;
			} else if (e.target[i].type != 'radio' || e.target[i].checked == true) {
				form_query += e.target[i].name + "=" + e.target[i].value;
			}
			if (i+1 != e.target.length) {
				form_query += '&';
			}
		}
		//alert(form_query);
		const response = await fetch(form_query);
		const text = await response.text();
		alert(text);
		location.href = "./";
		// TODO: reload page or not -> check error message
	});
});

var desc_tries_count = 0;
window.addEventListener("load", (event) => {
	(function loop() {
		setTimeout( async () => {
			console.log("DESC: " + desc_tries_count);
			
			const response = await fetch("./API/?CMD=DESC");
			const text = await response.text();
			console.log(text);
			if (text != "" && !text.startsWith('/')) {
				document.getElementById("Mplayer").value = text;
			} else if(desc_tries_count < 3) {
				desc_tries_count++;
				loop();
			}
		}, 1500);
	})();

});

</script>
</html>);


const char folderImage[] PROGMEM = "<img title=\"Folder\" width=\"20px\" style=\"margin-bottom:-4px\" src=\"data:image/png;base64,iVBORw0KGgoAAAANSUhEUgAAAEAAAABACAMAAACdt4HsAAAKyHpUWHRSYXcgcHJvZmlsZSB0eXBlIGV4aWYAAHja1VpZcsM6DvzHKeYI4gKCOA7XqrnBHH8apOx4y+Lk/Ty7YskUBYLdQBOUQ+N//530H7xi4kyRJSdN6cAralRfcJKP/Srr0x1xfa5XPC/h+107XS94NAUcw/6a09n/0u6uBvah4IxvDOV2Xqj3F/QcwecHQ34fgnlk5/00pKeh4PcFdxooe1pH0iy3U6hjH/tlJnn/kX3EfO/203cBep0xTvB+BBcOfIZwOhDsL1AoOFF8+qDo6HC0loBPFy7GAMgrnK4vhUdznFQ8d7pj5XrmXrfTI1vRn13CA8jpenzZTo4fLoTrOP4ufvJ55u/bAdk2dDygb39z9jzXnDGLEhOgTuekrqjZCfpVDGFDZ4Jr6RD8MUzIeiveGVHdEAr9aEfFuzl1HuhPF113xU031rG5BhejH+QFJ943H1ZjDuLVt2D8RXu76QWs9pDBZ1u0x+Cvvrg1rB6N1mgZI3eHrt7BmIXA229694Y5LRWcO/IVK/jlvYENN4w5+0Q3MOLmCSovgC/vx5fxGsAgG8qWIgpg6zZR2X0oQVhEB3RkHHcOOumnAUCEoRnOuAAGwJoL7JI7xHtxDkBmEFTgug/RVzDgmH2Hkz6GkMBN9jY0bhG3unr2aCa0Q8zABIcUBNwg70BWjIz4kZgRQ4UDR2ZOLJxZuaSQIIopJUkmikWCRBKWJCJZVEoOOWbOKUvOWXNRrwGiyZpUNKtqKRizwHLB3QUdSqm+hhorU01Vaq5aS0P4tNi4pSYtN22l+x469KOnLj137WW4gVAacfBIQ0YeOspEqM1AM06eacrMU2e5snbS+vR+gzV3suYXU9ZRrqyhVeRiwpmcsHEGwjxFB8bFKEBAe+PsyC5Gb8wZZ4dC/gJ7OMnGWXfGGBiMw3me7sId+c2oMfcn3kjiHW/+t8yRUfcmc8+8vWKt2zLUFmM7Cw3UIyD7cH3k4nOxxe7pSJ9dePf4LzI0am0HFgCZM8c2R58TOCH6ZnWza2jVvmtyI6XZe6UKeF1uqc+eahm4jZ11mRyczBFV7FtqZYZSR+o5NLAosZQ2uucRZ5eC1Zm8IkIrxzxD5KQTCp9BzuRmBpZVHG+swmaYw8U1QEeoLM88sS0IEDA4P7a7iA6B8Tm9n6OEnOfg2Vim6oArLGXIxHqz/C6acZOPlexrTXs6B8bCvckUXv0y2hVDp5nWuDPgfcAtPQTTc25iaHg/Q2h0ncdn2FzmsWehfpnEJPL9HGhPAj7m4cPE7Y7nSKJYR3lURT9zE52Xowh6c3U7ejc9svldp9dr3560iTcGH1hp2TXcBbx8na2BjeJrl0fAyRA/AQddtQCDPFtAZs4BU1LThMDUWVCKlRp9YV8FkcBtB91oEDacEP4OO/nd8SNs6Wdxexe20EOjJ29ygut2pCrGSFEeklJnYArpN98jpCeWPrVwjyNjmiH3WECj7xVOOHgT2SGuBlSwkz/sixXFXx8z9KiHJm6lH2Ie6+5ocGpNIwn1YlRMmwWPhkkI/Avaxpjdr1mUkWrrHkmlo7bawDuz07YZC3NzTiy9Jw7awU+JPSEPK7zuY0JHIdRpSe+AP4gTmGqzYJFEXkpF1rQQIK4IgEk75dwKAMRXTgIFKKoLSB/DGWNSFJ5KRmjh9gWzOlDCqVQUnI7JoqsAPKezWp6J5dnxkWcfY94POQAYYhxxic4tBxqlw0t4W5+8XYLv3TW3DOLlMALIXMZxubySgu78tazmUiaA4YRkTuXzyW69aLNvvSITjpgvglXjRBlgWhB2KlcGl5KLpXC3xF93ctiJvG7cGkGfo5OgnZAeNMhO3guuL2BFZK97n3B9QOdE1hbKsYYCug/g0me81KyooGa2e1G3QApsYQBSvQrGhWRBHoHZTKlZylB3baCEGMoSkbBZSg3YTcSCRNaFhPeJIR8YF+UNNg3cLWe45xS39h2GM6WARE9jBzpvUYJsnRnVGnJ69MUMOGQop8L9lusoYhKBPY/wkpFuChsAs35kM0qdbivRd8nMyJRDFE5pJZcxUrfaBuSHBHxQrvSeR4f6KUQIcpKkpN5bKwXRZetjRDEUIbrwbSLNMatE0E4RuzG4jH5pn0aIQmIPFQqgFU0+9aZYQwGeV8RqPDzcwhSO84SuZ5+cHDElu9M3B+S4zxUU92Tiu9KnfH7QCZ4QKGg5FosB6wJuajt0PersWGYlVGcMGBglX8JWQNIaQWsAIsgLV6Cvko5izNpwsVusK7aQkLauS9sBslDOezigZksvkmKpJBKraGtcUZdqYKz+AL4f0CXUAoKacUU9ppPyPqf1pWCPU9G5F9jTkacvPj13vvYF0zWM4VrJWndGEKDhEvaXdY7KuIRlMcvF3oe1T22RRezF1uX8wRZEA815XUHFjPIKoeitjK8Zi0JNR2NHa91VlxOCxmIWyySsnMH7RiNdWwXpDoYhXotfE5BmAnPym2yxheiNxCvzqqgtrNA9rzxZSNNqLg0pNo31ZrWHc5k/yETs3NG5LRv7Jv7J6p1KsgxB8RDBuHFUjyIJi3DYAhYj7PUV59KKDmxHom1xoz3zuj2h56bfnbw2BAFlLASYTmvV9GrHUY2lNmhWh1IkWx5Ul1wBFKM/QRwzluyO7Vi1yTnbvgACAINyMyZbQKDzwdastsvhZIVQZRQFcWy7JCt+1MpAyJCNjhTDSBP415UZR8PYzjlbIZbwNUi+Puoe/bCq+fb4ZAjwiMGzFbvu7DaIFkCXieSw53GFKNEFIGwJfwbQgscWihuAxMqaG3iWsrwAyB7zfAPRQf8QRE+GPiB6jqBbgG7g2QFE7wH0KoJ2ANF7EbSy7eXs6B+A59HQbyNoBxC9kWKPEVS2zneDPtMPYwh6ZFI9bWvUg7NFGxpd87EvRCasj1jNbbczDpMQg1WOFz2/6Ug/7pmBoX6OIZ2TTdm/AhGlypcYimFowdvoAUTTvzsQf5qHBP9tdQKMKB+TO7/uoFgrmP0w8YNG+nnXrxtpt16C8aL2tzCes/0KRaQqfQXjfBWKZldR9YaI/YBt/u3Z+Ri0qqU6sGJK6b7tfSG2gijdWj+w98BGmN0YHNmeayRsIPu5eMp+fNBtu9HobLdW2z5h4+K5tTxRLGms1RXdFmzr8th3WTgb6c5ywIYIxexoqM0dqy33iL940rxuH3U9sVhhuS7sTfsgtMOBcD/8pxN49ukyNt0Pfj/KdfAnn57Hpu/m/tOp03dz/+nU6bu5/3Tq9N3cfzp1+ivtl9Hpr7Rfxqa/0n6ZOr1Hu2A3/nqXRJcyOk5sEcLczxuODPMohp1t/nebDpTUQVBSV01LJi/1dG4QGyZeqojlWBTyjt2iPT/E5nKO9TgQO6OlB5mx7xwulf3UyC3N8qjiZ8UWLGghbPBtMxvsSYbOfJbntsGNwWHT3OcWNB+6q5+aCpO+GsWeQUDZtiEZ+4FmexjjHIGWnW1l2YAOHuux6qv2e+vb9mmZ3nH/a4zecP8r7+kd97/ynt5x/yvv6R33v/Ke3nH/K+/pL7Fz6yX9JXZuvae/xM6t9/SX2Lltp7/Ezq2P9JfYufWe/hI7t97Te7Ej3n786fZ7ST5/y4l9L0dWVaUZTe5RetovIXP9IpOh3zl5U9N5rB9ILkLaTk3dJd/lSI8Nvz3+SwzZOtft/2X+D3Iw4y/uunDuAAABhWlDQ1BJQ0MgcHJvZmlsZQAAeJx9kT1Iw1AUhU9TpVoqDnYQUchQnSyIijhKFYtgobQVWnUweekfNGlIUlwcBdeCgz+LVQcXZ10dXAVB8AfE1cVJ0UVKvC8ptIjxwuN9nHfP4b37AKFRYarZNQGommWk4jExm1sVA6/oxQiC8MEvMVNPpBcz8Kyve+qjuovyLO++P6tPyZsM8InEc0w3LOIN4plNS+e8TxxmJUkhPiceN+iCxI9cl11+41x0WOCZYSOTmicOE4vFDpY7mJUMlXiaOKKoGuULWZcVzluc1UqNte7JXxjKaytprtMaRhxLSCAJETJqKKMCC1HaNVJMpOg85uEfcvxJcsnkKoORYwFVqJAcP/gf/J6tWZiadJNCMaD7xbY/RoHALtCs2/b3sW03TwD/M3Cltf3VBjD7SXq9rUWOgP5t4OK6rcl7wOUOMPikS4bkSH5aQqEAvJ/RN+WAgVsguObOrXWO0wcgQ7NavgEODoGxImWve7y7p3Nu//a05vcDFElygYG5fqQAAA0YaVRYdFhNTDpjb20uYWRvYmUueG1wAAAAAAA8P3hwYWNrZXQgYmVnaW49Iu+7vyIgaWQ9Ilc1TTBNcENlaGlIenJlU3pOVGN6a2M5ZCI/Pgo8eDp4bXBtZXRhIHhtbG5zOng9ImFkb2JlOm5zOm1ldGEvIiB4OnhtcHRrPSJYTVAgQ29yZSA0LjQuMC1FeGl2MiI+CiA8cmRmOlJERiB4bWxuczpyZGY9Imh0dHA6Ly93d3cudzMub3JnLzE5OTkvMDIvMjItcmRmLXN5bnRheC1ucyMiPgogIDxyZGY6RGVzY3JpcHRpb24gcmRmOmFib3V0PSIiCiAgICB4bWxuczp4bXBNTT0iaHR0cDovL25zLmFkb2JlLmNvbS94YXAvMS4wL21tLyIKICAgIHhtbG5zOnN0RXZ0PSJodHRwOi8vbnMuYWRvYmUuY29tL3hhcC8xLjAvc1R5cGUvUmVzb3VyY2VFdmVudCMiCiAgICB4bWxuczpkYz0iaHR0cDovL3B1cmwub3JnL2RjL2VsZW1lbnRzLzEuMS8iCiAgICB4bWxuczpHSU1QPSJodHRwOi8vd3d3LmdpbXAub3JnL3htcC8iCiAgICB4bWxuczp0aWZmPSJodHRwOi8vbnMuYWRvYmUuY29tL3RpZmYvMS4wLyIKICAgIHhtbG5zOnhtcD0iaHR0cDovL25zLmFkb2JlLmNvbS94YXAvMS4wLyIKICAgeG1wTU06RG9jdW1lbnRJRD0iZ2ltcDpkb2NpZDpnaW1wOmNjZjg4MWM4LTNhOTEtNDkwOC1hNGNkLTQ0Y2VmMDQ2YTQ0OCIKICAgeG1wTU06SW5zdGFuY2VJRD0ieG1wLmlpZDowZGQ5MGFkMC1jZjE4LTRhNTEtYjdkNi1mNjUwYWI1NjM5NzkiCiAgIHhtcE1NOk9yaWdpbmFsRG9jdW1lbnRJRD0ieG1wLmRpZDpiMmE1YmM4ZC1jZTI4LTRiMTUtYTgyZC05MjUxY2Y3MjY3MzEiCiAgIGRjOkZvcm1hdD0iaW1hZ2UvcG5nIgogICBHSU1QOkFQST0iMi4wIgogICBHSU1QOlBsYXRmb3JtPSJXaW5kb3dzIgogICBHSU1QOlRpbWVTdGFtcD0iMTY5NTk4MTc5MDQzNzI1NSIKICAgR0lNUDpWZXJzaW9uPSIyLjEwLjMwIgogICB0aWZmOk9yaWVudGF0aW9uPSIxIgogICB4bXA6Q3JlYXRvclRvb2w9IkdJTVAgMi4xMCI+CiAgIDx4bXBNTTpIaXN0b3J5PgogICAgPHJkZjpTZXE+CiAgICAgPHJkZjpsaQogICAgICBzdEV2dDphY3Rpb249InNhdmVkIgogICAgICBzdEV2dDpjaGFuZ2VkPSIvIgogICAgICBzdEV2dDppbnN0YW5jZUlEPSJ4bXAuaWlkOjIxZTU3ZTU5LWRkZWEtNDdjOS04M2U2LTRmNDAzYzQ5ZDVmZCIKICAgICAgc3RFdnQ6c29mdHdhcmVBZ2VudD0iR2ltcCAyLjEwIChXaW5kb3dzKSIKICAgICAgc3RFdnQ6d2hlbj0iMjAyMy0wOS0yOVQxMjowMzoxMCIvPgogICAgPC9yZGY6U2VxPgogICA8L3htcE1NOkhpc3Rvcnk+CiAgPC9yZGY6RGVzY3JpcHRpb24+CiA8L3JkZjpSREY+CjwveDp4bXBtZXRhPgogICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgCiAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAKICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgIAogICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgCiAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAKICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgIAogICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgCiAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAKICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgIAogICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgCiAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAKICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgIAogICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgCiAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAKICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgIAogICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgCiAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAKICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgIAogICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgCiAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAKICAgICAgICAgICAgICAgICAgICAgICAgICAgCjw/eHBhY2tldCBlbmQ9InciPz5/W16HAAACKFBMVEUAAAAAAAD/tgD/ugD/uAD/ugD/uQD/uQD/uQD/uAD/uQD/uQD/uQD/uQD/xgD/vAD/uQD/uQD/uQD/uQD/tgD/ugD/uQD/uQD/uQD/uAD/gAD/ugD/uQD/uQD/ugD/qgD/uwD/uAD/twD/uQD/uQD/uQD/vwD/uQD/uQD/uAD/uQD/ugD/ugD/uAD/ugD/uQD/uQD/1Vf/0k3/zkT/yzj/zDP/z0T/yDT/zkL/zzD/0k7/xTD/01b/yDT/1Vb/zTL/0k//1Sv/zUH/z0P/zTr/z0X/00//1lrmlyfmlifwrSzyrS3upi3upy3/uQD/01n/557/337/117/11z/1lr/55//33//11//113/1lv/01r/56D/34D/12D/1lz/6KD/4IH/2GH/1Fn/4ID/2GD/1Fr/1Fz/6KH/2GL/ugL/2Gj/uwf/23X/34H/12H/wh//4Yr/z0v/5pz/wyb/34T/3nv/2m7/3Xb/xzP/23f/5Zf/223/uwb/xjD/1mP/5JT/4or/2WX/2GP/uwj/vhL/whv/xzH/z0r/1mL/3oD/5p3/5Zn/4IL/2GX/4Yb/2mr/6KL/5Zj/2Wj/2GT/4Yf/23D/55v/5JL/4oj/33r/22r/2WP/3nj/3nf/3XT/3HD/3G3/2mf/2WT/2Wb/2mb/2Wf/2mj/2mn/2Wn/2Wr/22n/22v/2mv/2Gb/2F/zuUfzuEbdgxzaexbbfRfbfhjbfhfehB3////H3xAhAAAAAXRSTlMAQObYZgAAAAFiS0dEAIgFHUgAAAAJcEhZcwAACxMAAAsTAQCanBgAAAAHdElNRQfnCR0KAwqumVOiAAAApElEQVRYw+3WoQ6DQBCEYdS9UF+jHgwCV1V1OYUpDkUCbSrq2gB9zLohTeAuzCD38/u73WyWGWMWbo06vyfh1IJTC5vzwefbinQg+DImTwWCr+KigfrU+ksCAs8190eTgsCbhMCNhMCHhMBIQqAnITCRjgt8SQh0JAtY4C8wk44LyLsgb6N8keSbKAfksz6QEHiREGhICFxJCJQkBM4k+4+NWfwAMmA4CWbXIpgAAAAASUVORK5CYII=\" />";

const char fileImage[] PROGMEM = "<img title=\"File\" width=\"20px\" style=\"margin-bottom:-4px\" src=\"data:image/png;base64,iVBORw0KGgoAAAANSUhEUgAAAEAAAABACAYAAACqaXHeAAAMFXpUWHRSYXcgcHJvZmlsZSB0eXBlIGV4aWYAAHjapZlpluO6DYX/cxVZAudhORzPyQ6y/HwgJZWH6ry8xO6yZJIiCdyLC9Ct5r/+udQ/eLmkrfIh5Vhi1Lx88cVWbrI+r7o/jfb7c7/81cX3t3b1dFiaHFd3vuZ4jb/bzTPBuVTuwstEuV8d7b2jXCvY/DGRPRcnO5L7cU1UromcPR3mmqAes3QsOb2a0Oa5jtuSfP6UfPj8vu2v7wnvjcA6ztrpjNN8OndtwMmfU65yU/i0rjDQcK27q3Ifr8lwyG9+el6FHa15QfE96A2V58783q4+0fL2GuI+nByf66/tyoSPDvesY9/4k687+95u0/G70h/el7+1Rl7bZqyoPuLqeBl1m7LvGNdYQpbOiq1FnfgLTJH2u/DOsLpDhaG7bry7KcYC1zLeDFPNMnNfu+ls0dupbOLG2m7dbswu2WK7E/y8vM2yCVSHyyDZN+ze2WcvZi9bdFd7tczKwzDUGiYTCvztt/q7D6wloWCMzo+v2Je14my2IcjJJ8NAxKzLqWE7+H5/vgRXB4JBvCwhUnBsO1O0YH6UwG2gHQMD1xODJo1rAlzE0oHNGAcCoGZcMNHoZG0yBkdmAKps3TpvGwiYEOxgk9Y7F8EmW1maR5LZQ22wNCvaETOQCC66BDbEHWB5H+BP8hkO1eCCDyHEkEIOJdTooo8hxpiiiGJNLnmVQooppZxKqtlln0OOOeWcS67FFodohhJLKrmUUitrVmauPF0ZUGuzzTXfgmqxpZZbabVDn+576LGnnnvpddjhBvox4kgjjzLqNBMqTT/DjDPNPMusC6otp5ZfYcWVVl5l1Qe1C9av999AzVyo2Y2UDEwParSmdE9hRE6CYAZgZBED4kkggNBWMNPZeG8FOcFMF+TPBcsmg2A2jCAGgn4aG5a5sVP2ICrI/V+4qeTfcLP/K3JKoPubyH3j9htqQ9JQ34idKBSnakf0MabazD9y1XNtpBdrUh9qudaweK1QR1/WMdMatowckl3DBO86aok0t+VF69YcaRafY2Da5tbdy47q21CUSQa0l7a3fh8z05c2fVqNyYJNRWZXMj15K3kwOE3S8nN39YVVfjaDWN+rBla1pL2lTlMNycSCkauv3GNqwelWhg0mdPw5kpN8MGPqZaZUWp6rQaC+QCBWwV8tA6vFlCrbz4Wly2RzC1gcQyNTlJWq7SbhTjbQJ57MNbTl1jI2ypBZ1GwyQdN1CcM6EOTmg/FB6on/7pqcm0bJNKuk7c6s5TPUWWIree1vq7cu165BfyQPp3JBGOE7cZb3TYwZhQymwFPxXOCTWEHVk5PiTQbApUgTO5UtBNPsTMYvYqiTYKMf04cySl+qrkhg2NyEpxEKQSPYS9S42UKYY6Q05xy543+Hp0ds00BOEmMRDhAIwAkh8ctYy068yy0WLeBzZUivbbNidQO1OUvuyYUWCDrDoguHxDl6SrK3oMqmO6lys75KrfefrzMs4hFU2R71AaDGRgSrGd13e6yx+xb1dlmFlLhre0qgKufL8ST+3U6krHnx5fvwYPGKbWwe/KYLofaWx0Y3ECPZrZSWqXXE0CfMxiYRUN+nQ1pyb1C2D/xkl5+xwsEoDdClRGFJj0Ym05QbCx1bVafR0lQDHuN6gsO2iLfbmsgQ6BBWoQdBRwhVC89QmKRN3zBSmzhku3/ZDnTKrJxkv9meBS40AXM5iZOxEDdgRGiahzBzrrhjebwvot5WiSuTwGUmMKe5ulXcDIjw6qkJKcbsTljhXBWiTyPTdeJOzV3l9YU6pBrCjh+t/3A1HVqdcEKKpcK54iZ0haHJ05Q+I2pOX0feiBqJmBytyAp4v8AKva5GdaiGDDrf9aGNhJ0QYo8AHsQeRwrSRftGAEwsE2lpzWpEpRKXRgm2S7xHtK2ayQVEF7QBACQre9wuPi+yX1q5sWSdZJaIEK6Yvbm8xlTyUMP6ZmPk4e6AtA1vKJYysQtsrlUiC9cb+mcb5HPCpE2kgWhAUTO1wtp6NKm8cPg8GlmoWNu8+aV/+DXMza9FQdDt1tSSgXe0I2w81Ahvci2EITm5QCGtK8/iYNSgb4KAKvVA/QE3xxetVO+iaRHNIQJR3hVzwa62fsO3++FSK1blsPUR0GQBidod2T+hbOdp64MC9E1D78gnffis/LhQfqCnRs2yQxFa62KYpY9gC8eFOVaR5NUWmivA427kXQK1KXa9RG4H6d178TB+lSyEKSSiWn2ruc0pyjsqGRb3LhnUJLR7Oz6uhZStkdPLbdD1jznHDNwnmUzSmVRtUAFujETk0bFRO32nBw0qiFkJTQu132KjRv3tRslFxKLaucjG33LQV7DYFzE1tKBXEsnEjEkKfdl5p3VTG+IRZXcOhIU5IpAJ/k6RWr+6UMOu7Retb+8c56gQ/to7h1ywWOgl5IJatUGteqRDREX9qIoUnCtZstvjE052m2F+3IpxjKRYvofcxqs3UdmacgsQqrlFB/WxcqzxxLaOuO5yDUS6jU79KiI+7a4r3Ekog3qhjiCpDJiYUNwUiW+hmqN63uRpJ9bI/H9Mq6Z1Vz/SZ60zkFXzW7OinQhw78zZdv8Sd28s0kX8Vy5eqG3y9sIU82mVWtwWYZP4ot2FsFTs2zWP1Z2iv5M7HBLp1aZzevIyqiAptOJI4qFKgq35kp+qv+vsfeXYsZSe6RRlNwnCoYeTIvLFL8f+LPZflZl3L1Gi1SZKEao8RDl5rB1SimnbJl2k6SbDdsQGJRx/KLm5QgatOGln6thLM0iKQRzZ0EDerr4ltZaUWJJpXBPbm4Zk6i+M1+ux/ZHXy/rYXzIuMnJ6/Da/lVfdfauojlXmMvTbavVt9h54NWbxVcsPKTynVsrxVkGBSokyn3PjbJQ/qjbJrDoB/URkpM6AV9aNETe7WfxPFcVMhE9zRxpV2MEmZOJU0wrKLfn29om7LUcWzCUL7BHR/Axj9YB9G7DpfKHdvngft5fiDyEu5nd1T8LJ+8V0Tu3kFhhBuQ5olHUjkQE5/uyyPeevolp9hLuorB4CuHxcpiXKCYTWORHacAmOeCNKTVN0k3M/0cmWofu14aOxB0MtjXRre0fw5QD9DEZCt/FB/c55Lz9GvDgpeNx/mS1H5Rbkd6TULqspUalqyZ9UONSB3yXGexLgfJLjDmbqFL2rbTJAAu+eE0XErpDCXK+d0TyI37slEXxad/TLbY4r4kpQvcY/sOajbZeT5DhyGylslyFVyyNj/yLDFxXux42nvsvAQnaXoszFXcFF6mlfD2spIKlLpcyOpOIUF+e7KH7BPvXXjoFAbW3bcYFYv21HTCnvg7t71E9X1OEWwXhHLqfWY8S17f5J/Scg1GnOcn8C/zNU4m15lf8SuCLkct9FvGDbqWo5Py3OBbii4FfOLMjC4HyWkxTCl1s8jqNQNp5EV1bUH2xRv3iF0tmvQmFygmRRlEymQml1RYIdAdg5O1MA45QRSEjkYCU/VcivEhw97MgNcyhxphT/HcXy1HhS4gOXiEeoUEH2g3+pk3flSz0p39VLg3ZUsFCvyg9K0lYjbM0rnSKZs1bze9afIwb03f7mUGP3Iz+9FBGRmeS0Npw78l4pb6ewmyrgsGuvztpWTgl7x0oeB5MkDNeWoXfPOcT49vko2S9vBzg5aNLjt5qqZWZ9b5IWtrzjBG1f17w/s744Q4d2eU19um1P9Ta0y9D09ITTk6QAzJcL8I8SHwBjxb4e2ZwMs/1kBgk56zlIDpcJuSoF/54u4ES+rWlXTWgT53IVOdpxSso4R1NlEy1HdaV8/EP6pTJyXY8ZRZxslBPeGsrtcm92auMQCURXOFAU4mD0EH3KmQkzYr8S55nMoLxIEzWXHLCElBS6lbStRBnL3rmVjDhNpJwzkDlz2oexs9h7Aip0SoparbNiD8cr4vr0ZKM2+6COw2MNLgccwTpzz0i9ytmFGy9DrEvhEJ5BUn3VPYjgkx8QTge5ersRqwObE/KdzXnvziHwUCPUaE4WFmBJVbyJ0aQb4s9b+k6P48CfNqfllysC/TIrDxI6ZQKb9qdiWpTN5Dq/gztWJb+GcCTnhG1FB4nRIqfkLbKNYy4zmfFVPstRDjb/G7njkzveblugAAABhWlDQ1BJQ0MgcHJvZmlsZQAAeJx9kT1Iw1AUhU9TpVoqDnYQUchQnSyIijhKFYtgobQVWnUweekfNGlIUlwcBdeCgz+LVQcXZ10dXAVB8AfE1cVJ0UVKvC8ptIjxwuN9nHfP4b37AKFRYarZNQGommWk4jExm1sVA6/oxQiC8MEvMVNPpBcz8Kyve+qjuovyLO++P6tPyZsM8InEc0w3LOIN4plNS+e8TxxmJUkhPiceN+iCxI9cl11+41x0WOCZYSOTmicOE4vFDpY7mJUMlXiaOKKoGuULWZcVzluc1UqNte7JXxjKaytprtMaRhxLSCAJETJqKKMCC1HaNVJMpOg85uEfcvxJcsnkKoORYwFVqJAcP/gf/J6tWZiadJNCMaD7xbY/RoHALtCs2/b3sW03TwD/M3Cltf3VBjD7SXq9rUWOgP5t4OK6rcl7wOUOMPikS4bkSH5aQqEAvJ/RN+WAgVsguObOrXWO0wcgQ7NavgEODoGxImWve7y7p3Nu//a05vcDFElygYG5fqQAAA0YaVRYdFhNTDpjb20uYWRvYmUueG1wAAAAAAA8P3hwYWNrZXQgYmVnaW49Iu+7vyIgaWQ9Ilc1TTBNcENlaGlIenJlU3pOVGN6a2M5ZCI/Pgo8eDp4bXBtZXRhIHhtbG5zOng9ImFkb2JlOm5zOm1ldGEvIiB4OnhtcHRrPSJYTVAgQ29yZSA0LjQuMC1FeGl2MiI+CiA8cmRmOlJERiB4bWxuczpyZGY9Imh0dHA6Ly93d3cudzMub3JnLzE5OTkvMDIvMjItcmRmLXN5bnRheC1ucyMiPgogIDxyZGY6RGVzY3JpcHRpb24gcmRmOmFib3V0PSIiCiAgICB4bWxuczp4bXBNTT0iaHR0cDovL25zLmFkb2JlLmNvbS94YXAvMS4wL21tLyIKICAgIHhtbG5zOnN0RXZ0PSJodHRwOi8vbnMuYWRvYmUuY29tL3hhcC8xLjAvc1R5cGUvUmVzb3VyY2VFdmVudCMiCiAgICB4bWxuczpkYz0iaHR0cDovL3B1cmwub3JnL2RjL2VsZW1lbnRzLzEuMS8iCiAgICB4bWxuczpHSU1QPSJodHRwOi8vd3d3LmdpbXAub3JnL3htcC8iCiAgICB4bWxuczp0aWZmPSJodHRwOi8vbnMuYWRvYmUuY29tL3RpZmYvMS4wLyIKICAgIHhtbG5zOnhtcD0iaHR0cDovL25zLmFkb2JlLmNvbS94YXAvMS4wLyIKICAgeG1wTU06RG9jdW1lbnRJRD0iZ2ltcDpkb2NpZDpnaW1wOjU3MTExMDZjLTRlZGQtNGU4MC04YTI0LTNhYWE2ODVjZjkyMyIKICAgeG1wTU06SW5zdGFuY2VJRD0ieG1wLmlpZDpmNDU0MmM0NS1lZTFmLTRjMTctYTFkNy04YTMxMGRiOWUzN2EiCiAgIHhtcE1NOk9yaWdpbmFsRG9jdW1lbnRJRD0ieG1wLmRpZDo5NzEyYzYyYS1hNDBiLTQ5ZWUtOWFkNi03MWQ1YWFlZGI5NWUiCiAgIGRjOkZvcm1hdD0iaW1hZ2UvcG5nIgogICBHSU1QOkFQST0iMi4wIgogICBHSU1QOlBsYXRmb3JtPSJXaW5kb3dzIgogICBHSU1QOlRpbWVTdGFtcD0iMTY5NTk4MTczNjA4MDM0MSIKICAgR0lNUDpWZXJzaW9uPSIyLjEwLjMwIgogICB0aWZmOk9yaWVudGF0aW9uPSIxIgogICB4bXA6Q3JlYXRvclRvb2w9IkdJTVAgMi4xMCI+CiAgIDx4bXBNTTpIaXN0b3J5PgogICAgPHJkZjpTZXE+CiAgICAgPHJkZjpsaQogICAgICBzdEV2dDphY3Rpb249InNhdmVkIgogICAgICBzdEV2dDpjaGFuZ2VkPSIvIgogICAgICBzdEV2dDppbnN0YW5jZUlEPSJ4bXAuaWlkOjUyMjI0MWIyLTE3MDMtNGYzNC1hZTNkLTVhZjkxMzgzMTIwYSIKICAgICAgc3RFdnQ6c29mdHdhcmVBZ2VudD0iR2ltcCAyLjEwIChXaW5kb3dzKSIKICAgICAgc3RFdnQ6d2hlbj0iMjAyMy0wOS0yOVQxMjowMjoxNiIvPgogICAgPC9yZGY6U2VxPgogICA8L3htcE1NOkhpc3Rvcnk+CiAgPC9yZGY6RGVzY3JpcHRpb24+CiA8L3JkZjpSREY+CjwveDp4bXBtZXRhPgogICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgCiAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAKICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgIAogICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgCiAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAKICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgIAogICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgCiAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAKICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgIAogICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgCiAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAKICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgIAogICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgCiAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAKICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgIAogICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgCiAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAKICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgIAogICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgCiAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAKICAgICAgICAgICAgICAgICAgICAgICAgICAgCjw/eHBhY2tldCBlbmQ9InciPz4POw2QAAAABmJLR0QAQwBDAEN7GbpVAAAACXBIWXMAAAsTAAALEwEAmpwYAAAAB3RJTUUH5wkdCgIQSuCbmQAABydJREFUeNrtW8+LHEUU/l51dffsjmaTY/4CRUGEgAgBT15EkSyiIOItHvSf8G/w4MkNih4ERRDBgzcPKl4SJIjExEhAMSAhu667YWa6qp6H/lXVXf1jZmo2ATNhd2p6qmf2fe/73vuqugM8fPy/HzRm0q0//oy3JpOIuTzC1VN1qBix+8t53TzdmcX1WGuNxSLDnbv76vwz59QmAZBDE7759jsx3d5+d7q19Uoz2CYA7LzF9rRWkM4YAJcgMWCMgUqVjmN5/crVnz+7e/DPl88/d352XwAAiNIkOTuZpI/XyWxAwc3s1q/ZnsvtgJ3gS2zYQJsYsZRPxlH0EhvzxY+Xf3r72XNPH4QGQAxNYCtPzFwFb79mK0KuAuEq+HwaVxlujrkYl+cDBCKClBJJksTbk/S1U9Otves3b50+eQC4pLMdeJ11O9g6g+64Fbgv640xQCBBiGQEIYQAsCtltHftt99PnygABQJusOgOtmKMM4YbuJX1al6TDQUIQgjIWEIbLSZpspsm8aWQIIySANc8rgudFSAawXZRfyjwJmMABhEhkjEAQhRFIk3TC2kSX7p2IwwIIyTAbbp7GDBe57CChTf7dkdgAEQAkQAzQ5YgpPGlazdunjmRGoBOnbtZ89K9pXO2QOAaBKcVWjJgt2PIKLJASPbWBWEUA7jR1rp07qvovXSHnzE2CFwAb5irztACYY2aMFwEqwroa2ur65wHpMLOP4CIQADiWLZBWKMwymUYMGRkbOvLXufHrqyqjHfNz4eC8m5wZ38fB4eHUErBGAYIEEKIWMoLgoiv/vLrxaeeeOwgMABuxn3ODa0e3gFC17kDIAghIKXEfD7H8fExZrM55os5FvMF7t27h/l8Jra3p7tbW1v4/KuvL7768osHQRnQ+8d3Bd4Ye62vd91gZz9HX0qJNE0RiQhJkmB7axtKayilkGULzGYzzGczkWWLXbWY73/wyafvvPXm69lGGNAPwhi698z3SYAAKSWiKAKndh0qiqMxyJTCfDbD0fGRSO7uv6HM/ocAfghXBMfa14G2Zvf55nxm21aXx9hhDhHVP0JACAERRYilRDqZYDp9BDs7O5MzO6deeG/vYwpXBC3vvxTFl9B5vaji4SJpLcAIAAmBKMrlMZ1OabbIzorobwFABwLAzewqIPTp3NlTYHcZPQgY1+yIoghJmmIymdCj0+0wRdAUJmS5tjamLrif5y2IzO09h9byO3+molXGcYw0TYmC+gDD3j/aV9FtD49V6e4L3J7L/g0XIUTuFqMISRIHrAEwTnZD6LyvHXZm2gbHCpxQrJiKsYgi5/31JGAYxrTb4FI6H8z0EGBWwE7NyLXvACEEBJXGOaQVXsa+gjegc2dfGQSq9rSbDMjDD8SAejvsJNrasM67Aq+H+fscDAB2DckY+7ppnXupb5GeAGLDFBgAdnaJe+2rR+edmh9Dd0+wXePyFbMJWQOagQfQuY/uS+jcHVez8/QTwByMAeW+YDj76qvofW3Np/NW4C5TyGgdjgHr6tx3BWlUWxugPnnPyWcYE0oC9oJoKbpvSudWzq0x1ZQAAVBBGeDsCK1pX0PpvA8EAmmtw9SA+qLHcjpf1r526ryX7nbgxTkFnkYpBG6DG7Svg23Nr/M2M6pnCicB9PXzcPZ1DN0dnXeCkL/USgXeEVpjmdpvX1fUuQcEewGkdCAJwHKCQe3rOjp36O4DgUiFZEB39sPq3Jfpbp032VWGnv9oFbAG8Am2tfE6p27JAJQF7QLgzdvXHlNjZ71VF6ieaX+PyrJwAIC7tR/GvnYxg8axpQUCwtWA1n0Bay1Tx9LdM38ABLJrAggqmASsOvAg6bwZuDtmyoJKYGM699O9r/+3wbNrQZ2YcG0w8DI1oM69gZefkKkTZMCqzm1VunfOrXGAygI6QRpdtQfo2xt4I6Pe89pZb7bCWgJZuC2x6ssD2tdhnY+ku9cPEKmQRoiKe3fvp879YDQMENVZy7JgbZDvS1sbl+kmEzdghJgbX7LOMpW6dd7f1uqdHgxkv/zcYD4A4Cr49ZepK7Y1al/4qM6paQB7GHQ5TK2AV1umYkxbG6tzDwiOEdLBiqDdBTZnX/va2lD2m+8DRFrp8AxYd5k6qPPe89uZbgVencMBrwtUt6g9WDr3Zr98ZpAOBUB5AxJaXmAN+xpA5wN+hIw2Ydsg0QrWlzqWz0tkvTmvM+vWOcyANoEYYIzhf4+OvwcoAZisuz+pAqjeM6TydQEIEdWUz8sIAaLctqCSXLW4LNQIrbpDVsD5gB1cATD+un378vHx0airo6No8v7eR5FSC2mUEsYYaG2gjYbRBlpr1McUaW1gimOmuJfXGE1sDLQxYFMeM2SMKf6PoAEbU9yQZag4n8rPyO8J1vm5bCh/ZrAxYGbK55jiUr6hw8NDffXK5eNsMR9Hg4ePh4//7+M/I9MHau15Z8kAAAAASUVORK5CYII=\" />";

#endif
